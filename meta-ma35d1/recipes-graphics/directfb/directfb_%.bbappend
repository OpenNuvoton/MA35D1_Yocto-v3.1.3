# directfb with tslib plugin
PACKAGECONFIG_append = " linuxinput tslib"

