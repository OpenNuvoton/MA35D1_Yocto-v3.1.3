FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://psplash-start.service"
