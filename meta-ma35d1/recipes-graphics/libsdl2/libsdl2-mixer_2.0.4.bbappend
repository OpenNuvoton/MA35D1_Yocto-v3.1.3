DEPENDS += "tremor"
RDEPENDS_${PN} = "tremor"
