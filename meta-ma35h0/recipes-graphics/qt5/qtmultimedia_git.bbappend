FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI+="file://qgstvideorender_disable_timeout.patch"

