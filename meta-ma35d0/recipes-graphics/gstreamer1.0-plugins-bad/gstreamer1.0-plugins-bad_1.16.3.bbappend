FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI+="file://0001-Add-nufbdevsink-plugin-for-MA35D0-VC8000.patch"
