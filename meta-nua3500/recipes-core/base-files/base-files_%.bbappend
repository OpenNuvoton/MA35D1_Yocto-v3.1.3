FILESEXTRAPATHS_prepend_nua3500 := "${THISDIR}/${PN}:"
